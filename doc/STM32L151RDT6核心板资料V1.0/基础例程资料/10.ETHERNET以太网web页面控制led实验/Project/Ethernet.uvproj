# Keil uVision project Ethernet.uvproj, settings and files
target Ethernet (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Ethernet +hex
  c flags: Optim=1
  c include: ..\Driver;..\main;..\STM32L1xx_StdPeriph_Driver\inc;..\STM32L1xx_StdPeriph_Driver\src;..\Driver\enc28j60;..\Driver\led;..\Driver\net;..\Driver\spi;..\Driver\adc;..\Driver\temp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group startup
    ./: startup_stm32l1xx_md.s
  group stm32l_lib
    ../STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group main
    ../main/: main.c system_stm32l1xx.c
  group spi
    ../Driver/spi/: spi.c
  group enc28j60
    ../Driver/enc28j60/: ENC28J60.C
  group net
    ../Driver/net/: ip_arp_udp_tcp.c simple_server.c
  group led
    ../Driver/led/: led.c
  group adc
    ../Driver/adc/: adc.c
  group temp
    ../Driver/temp/: TEMP.C
