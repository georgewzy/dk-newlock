# Keil uVision project gprs.uvprojx, settings and files
target GPRS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: gprs +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\My_File\CONFIG;..\My_File\STM32;..\My_File\SYSTEM\delay;..\My_File\SYSTEM\sys;..\My_File\MODULE\GU906;..\My_File\MODULE\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MAIN
    ../My_File/: main.c
    ../My_File/CONFIG/: config.c
  group USART
    ../My_File/MODULE/usart/: printf.c usart1.c usart4.c
  group MODULE
    ../My_File/MODULE/GU906/: GU906.c
    ../My_File/SYSTEM/sys/: sys.c
    ../My_File/SYSTEM/delay/: delay.c
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
